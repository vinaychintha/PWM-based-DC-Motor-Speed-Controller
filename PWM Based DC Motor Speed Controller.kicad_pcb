# Repository vinaychintha/PWM-based-DC-Motor-Speed-Controller

## KiCad design PWM Based DC Motor Speed Controller.kicad_pcb

Parts:
C1, C2: 10 nf; C_2220_5650Metric_Pad1.97x5.40mm_HandSolder
D1: LED; LED_1206_3216Metric
D2, D3, D4: DIODE; D_0805_2012Metric
M1: Motor_DC; LED_D1.8mm_W3.3mm_H2.4mm
Q1: TIP122; TO-220-3_Vertical
R1, R2: 1 K; R_1206_3216Metric
R3: 100 K; R_1206_3216Metric
RV1: 100 K; Potentiometer_Bourns_3269W_Vertical
TP1: + ve; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
TP2: - ve; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
U1: LM555xM; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/2D: D2.2 (A), D3.1 (K), R2.2, U1.6 (THR)
/C1: C1.1, U1.5 (CV)
/VCC: U1.2 (TR), U1.4 (R), U1.8 (VCC)
unnamed: C1.2, C2.2, Q1.3 (E), R3.2, TP2.1, U1.1 (GND)
unnamed: C2.1, RV1.2, U1.7 (DIS)
unnamed: D1.1 (K), R1.1
unnamed: D1.2 (A), D4.2 (A), M1.1 (+), R2.1, TP1.1
unnamed: D2.1 (K), RV1.3
unnamed: D3.2 (A), RV1.1
unnamed: D4.1 (K), M1.2 (-), Q1.2 (C)
unnamed: Q1.1 (B), R3.1, U1.3 (Q)

Board: 2 copper layers, 101.6 x 50.8 mm, 15 parts (0 on the bottom side), 11 nets.

## Commit log

2021-03-19 PWM based DC motor speed controller
